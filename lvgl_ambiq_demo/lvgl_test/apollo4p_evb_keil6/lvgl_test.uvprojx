# Keil uVision project lvgl_test.uvprojx, settings and files
target lvgl_test (6160000::V6.16::ARMCLANG)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.2
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: lvgl_test
  AfterMake: fromelf --bin --output bin\lvgl_test.bin bin\lvgl_test.axf
  AfterMake: fromelf -cedrst --output bin\lvgl_test.txt bin\lvgl_test.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_FREERTOS LV_AMBIQ_FB_RESY=390 NEMA_CUSTOM_MALLOC_INCLUDE=\"lv_ambiq_nema_hal.h\" LV_CONF_INCLUDE_SIMPLE AM_PACKAGE_BGA LV_AMBIQ_FB_REFRESH_TWO AM_PART_APOLLO4P AM_UTIL_FAULTISR_PRINT NEMA_USE_CUSTOM_MALLOC LV_AMBIQ_FB_USE_RGB888=0 LV_AMBIQ_FB_RESX=390 LV_AMBIQ_FB_USE_RGB565=1 WAIT_IRQ_BINARY_SEMAPHORE=1 NEMA_PLATFORM=apollo4p_nemagfx LV_LVGL_H_INCLUDE_SIMPLE keil6
  c include: ../../../bsp/boards/apollo4p_evb;../../../modules/FreeRTOSv10.5.1/Source/portable/Keil6/AMapollo4;../../../bsp/gpu/NemaGFX_SDK/common/mem;../../../;../src;../../../lvgl_ambiq_porting;../../../bsp/gpu/NemaGFX_SDK/include/tsi/NemaDC;../../../modules/FreeRTOSv10.5.1/Source/include;../../../LVGL_V8/src;../../../bsp/utils;../../../bsp/mcu/apollo4p/hal;../../../bsp/gpu/NemaGFX_SDK/NemaGFX;../../../bsp/devices;../../../bsp/gpu/NemaGFX_SDK/include/tsi/common;../../../bsp/gpu/NemaGFX_SDK/NemaDC;../../../bsp/gpu/NemaGFX_SDK/include/tsi/NemaVG;../../../bsp/gpu/NemaGFX_SDK/include/tsi/NemaGFX;../../../bsp/mcu/apollo4p;../../../bsp/CMSIS/AmbiqMicro/Include;../../../bsp/gpu/config/apollo4p_nemagfx;../../../bsp/CMSIS/ARM/Include;../../../LVGL_V8/src/gpu;../../../bsp/mcu/apollo4p/hal;../../../bsp/mcu/apollo4p/hal/mcu
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  group LVGL_textarea
    ../../../LVGL_V8/src/widgets/: lv_textarea.c
  group LVGL_misc
    ../../../LVGL_V8/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL_calendar
    ../../../LVGL_V8/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group LVGL_btnmatrix
    ../../../LVGL_V8/src/widgets/: lv_btnmatrix.c
  group LVGL_qrcode
    ../../../LVGL_V8/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group LVGL_png
    ../../../LVGL_V8/src/extra/libs/png/: lodepng.c lv_png.c
  group LVGL_objx_templ
    ../../../LVGL_V8/src/widgets/: lv_objx_templ.c
  group LVGL_core
    ../../../LVGL_V8/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL_spinner
    ../../../LVGL_V8/src/extra/widgets/spinner/: lv_spinner.c
  group LVGL_draw
    ../../../LVGL_V8/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL_bar
    ../../../LVGL_V8/src/widgets/: lv_bar.c
  group LVGL_basic
    ../../../LVGL_V8/src/extra/themes/basic/: lv_theme_basic.c
  group LVGL_span
    ../../../LVGL_V8/src/extra/widgets/span/: lv_span.c
  group LVGL_switch
    ../../../LVGL_V8/src/widgets/: lv_switch.c
  group LVGL_chart
    ../../../LVGL_V8/src/extra/widgets/chart/: lv_chart.c
  group LVGL_mono
    ../../../LVGL_V8/src/extra/themes/mono/: lv_theme_mono.c
  group LVGL_slider
    ../../../LVGL_V8/src/widgets/: lv_slider.c
  group LVGL_roller
    ../../../LVGL_V8/src/widgets/: lv_roller.c
  group LVGL_led
    ../../../LVGL_V8/src/extra/widgets/led/: lv_led.c
  group LVGL_colorwheel
    ../../../LVGL_V8/src/extra/widgets/colorwheel/: lv_colorwheel.c
  group LVGL_keyboard
    ../../../LVGL_V8/src/extra/widgets/keyboard/: lv_keyboard.c
  group LVGL_meter
    ../../../LVGL_V8/src/extra/widgets/meter/: lv_meter.c
  group LVGL_tabview
    ../../../LVGL_V8/src/extra/widgets/tabview/: lv_tabview.c
  group LVGL_font
    ../../../LVGL_V8/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group LVGL_default
    ../../../LVGL_V8/src/extra/themes/default/: lv_theme_default.c
  group LVGL_canvas
    ../../../LVGL_V8/src/widgets/: lv_canvas.c
  group LVGL_btn
    ../../../LVGL_V8/src/widgets/: lv_btn.c
  group FreeRTOSv10.5.1_AMapollo4
    ../../../modules/FreeRTOSv10.5.1/Source/portable/GCC/AMapollo4/: port.c
  group LVGL_imgbtn
    ../../../LVGL_V8/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group LVGL_freetype
    ../../../LVGL_V8/src/extra/libs/freetype/: lv_freetype.c
  group src
    ../../../lvgl_ambiq_demo/lvgl_test/src/: am_resources.c gui_task.c lvgl_test.c rtos.c
  group LVGL_img
    ../../../LVGL_V8/src/widgets/: lv_img.c
  group LVGL_table
    ../../../LVGL_V8/src/widgets/: lv_table.c
  group LVGL_fsdrv
    ../../../LVGL_V8/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
  group LVGL_hal
    ../../../LVGL_V8/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL_gif
    ../../../LVGL_V8/src/extra/libs/gif/: gifdec.c lv_gif.c
  group LVGL_flex
    ../../../LVGL_V8/src/extra/layouts/flex/: lv_flex.c
  group LVGL_grid
    ../../../LVGL_V8/src/extra/layouts/grid/: lv_grid.c
  group LVGL_checkbox
    ../../../LVGL_V8/src/widgets/: lv_checkbox.c
  group LVGL_animimg
    ../../../LVGL_V8/src/extra/widgets/animimg/: lv_animimg.c
  group LVGL_tileview
    ../../../LVGL_V8/src/extra/widgets/tileview/: lv_tileview.c
  group LVGL_spinbox
    ../../../LVGL_V8/src/extra/widgets/spinbox/: lv_spinbox.c
  group LVGL_win
    ../../../LVGL_V8/src/extra/widgets/win/: lv_win.c
  group LVGL_rlottie
    ../../../LVGL_V8/src/extra/libs/rlottie/: lv_rlottie.c
  group LVGL_label
    ../../../LVGL_V8/src/widgets/: lv_label.c
  group LVGL_arc
    ../../../LVGL_V8/src/widgets/: lv_arc.c
  group LVGL_list
    ../../../LVGL_V8/src/extra/widgets/list/: lv_list.c
  group LVGL_snapshot
    ../../../LVGL_V8/src/extra/others/snapshot/: lv_snapshot.c
  group LVGL_sjpg
    ../../../LVGL_V8/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
  group ThinkSi_apollo4p_nemagfx
    ../../../bsp/gpu/config/apollo4p_nemagfx/: nema_dc_hal.c nema_hal.c
  group LVGL_msgbox
    ../../../LVGL_V8/src/extra/widgets/msgbox/: lv_msgbox.c
  group LVGL_dropdown
    ../../../LVGL_V8/src/widgets/: lv_dropdown.c
  group LVGL_bmp
    ../../../LVGL_V8/src/extra/libs/bmp/: lv_bmp.c
  group LVGL_line
    ../../../LVGL_V8/src/widgets/: lv_line.c
  group utils
    ../../../bsp/utils/: am_util_delay.c am_util_stdio.c
  group devices
    ../../../bsp/devices/: am_devices_display_generic.c am_devices_tma525.c
  group LVGL_ambiq_support
    ../../../lvgl_ambiq_porting/: display_task_fake.c display_task_one_and_partial_fb.c display_task_one_fb.c display_task_two_fb.c lv_ambiq_font_align.c lv_ambiq_fs.c lv_ambiq_misc.c lv_ambiq_nema_hal.c lv_ambiq_touch.c
    ../../../LVGL_V8/src/gpu/: lv_ambiq_decoder.c
  group LVGL_gpu
    ../../../LVGL_V8/src/gpu/: lv_gpu_ambiq_nema.c
  group FreeRTOSv10.5.1_MemMang
    ../../../modules/FreeRTOSv10.5.1/Source/portable/MemMang/: heap_4.c
  group FreeRTOSv10.5.1_Source
    ../../../modules/FreeRTOSv10.5.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
  group keil6
    ../../../lvgl_ambiq_demo/lvgl_test/apollo4p_evb_keil6/: startup_keil6.s
  group lib
    ../../../lvgl_ambiq_porting/gpu_lib_apollo4/keil6/bin/: lvgl_ambiq_porting.lib
    ../../../bsp/gpu/config/apollo4p_nemagfx/keil6/bin/: lib_nema_apollo4p_nemagfx.lib
    ../../../bsp/CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
  group board
    ../../../bsp/boards/apollo4p_evb/: am_bsp.c am_bsp_pins.c
  group com_hal
    ../../../bsp/mcu/apollo4p/hal/: am_hal_access.c am_hal_adc.c am_hal_audadc.c am_hal_dcu.c am_hal_global.c am_hal_gpio.c am_hal_i2s.c am_hal_otp.c am_hal_pdm.c am_hal_pin.c am_hal_pwrctrl.c am_hal_queue.c am_hal_security.c am_hal_stimer.c am_hal_timer.c am_hal_usb.c am_hal_wdt.c
  group mcu_hal
    ../../../bsp/mcu/apollo4p/hal/mcu/: am_hal_bootrom_helper.c am_hal_cachectrl.c am_hal_card.c am_hal_card_host.c am_hal_clkgen.c am_hal_cmdq.c am_hal_dsi.c am_hal_fault.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_mpu.c am_hal_mram.c am_hal_mspi.c am_hal_reset.c am_hal_rtc.c am_hal_sdhc.c am_hal_secure_ota.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_utils.c
  group LVGL_extra
    ../../../LVGL_V8/src/extra/: lv_extra.c
